# Keil uVision project wake_mdr32.uvproj, settings and files
target wake_mdr32 (ARM-ADS)
  device: MDR32F9Q2I Milandr
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x08000000-0x0801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: wake_mdr32
  c flags: Optim=1
  c include: ..\wake_mdr32;.\Config;.\System
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Main
    ./: main.c led.c
  group Wake
    ./: Commands.c Port.c
  group System
    ./System/: system_MDR32F9Qx.c MDR32Fx.h startup_MDR32F9Qx.s
  group Config
    ./Config/: MDR32F9Qx_board.h MDR32F9Qx_config.h
